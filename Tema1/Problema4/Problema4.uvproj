# Keil uVision project Problema4.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8xC51RD+ NXP
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0-0x2FF) CLOCK(33000000) MODP2
  output: Problema4
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: t1p4.a51
